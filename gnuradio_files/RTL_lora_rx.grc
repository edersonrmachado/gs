options:
  parameters:
    generate_options: qt_gui
    id: RTL_lora_rx
    output_language: python
    title: RTL_lora_rx
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '433000000'
  states: {}
- name: gain_rx
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx time samples"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
