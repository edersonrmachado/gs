options:
  parameters:
    generate_options: qt_gui
    id: RTL_lora_rx
    output_language: python
    title: RTL_lora_rx
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '433000000'
  states: {}
- name: gain_rx
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"RTL Rx1"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"RTL RX 2"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    dev_args: '"serial=00000001"'
    gain: '10'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_rtlsdr_source_0_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    dev_args: '"serial=00000002"'
    gain: '10'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_rtlsdr_source_0_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
